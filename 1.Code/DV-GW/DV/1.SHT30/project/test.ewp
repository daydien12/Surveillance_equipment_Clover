# IAR project test.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\library; ..\user
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Header
    ../user/: dv_conver.h dv_delay.h dv_device_command.h dv_i2c.h dv_ringbuffer.h dv_sht30.h dv_uart.h
  group library
    ../library/: STM8CONFIG.h stm8s.h stm8s_conf.h stm8s_it.c stm8s_it.h
  group user
    ../user/: dv_conver.c dv_delay.c dv_device_command.c dv_i2c.c dv_ringbuffer.c dv_sht30.c dv_uart.c main.c
