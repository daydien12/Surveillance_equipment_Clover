# Keil uVision project gateway.uvprojx, settings and files
target user (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gateway
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group inc
    ../USER/: gw_conver.h gw_delay.h gw_sys.h gw_gpio.h gw_define.h gw_uart.h gw_device_command.h gw_ringbuffer.h gw_test.h
  group src
    ../USER/: main.c gw_conver.c gw_delay.c gw_sys.c gw_gpio.c gw_uart.c gw_device_command.c gw_ringbuffer.c gw_test.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
